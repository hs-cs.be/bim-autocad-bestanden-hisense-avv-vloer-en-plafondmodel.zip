Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-03-12T10:09:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 12 10:09:13 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{12E0EF9D-7818-40F0-9D50-21C0AF6EEAFD}\ifc * Database version: 5507 * Database creation date: Mon Mar 12 10:09:13 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 12 10:09:13 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 12 10:09:13 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcUnitaryEquipment: AVV-27URSCB, HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVV_INT-EN:AVV-27URSCB:1303938
In: V00
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 216-216-216, Color RGB 075-079-084
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 680 mm; Drain Diameter: 32 mm; Height: 230 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 9.53 mm; Width: 1285 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Ceiling and Floor Type; Article Type: AVV-27URSCB; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Ceiling and Floor Type; EMCS Version: 3.0; ETIM Article Class: EC000403; Family Version: 11.13; Manufacturer: Hisense; Manufacturer Art. No.: AVV-27URSCB; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVV-27URSCB; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: AVV Series; Revit Version: 2016; Type Name: AVV-27URSCB; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Mechanical - Loads - Airflow Rate (m3/min): 18.2; Cooling Capacity (kW): 8.4; External Static Pressure (Pa): 0; Fan Motor Output (kW): 0.07; Heating Capacity (kW): 9.6; Unit Weight (kg): 39
Type - Other - Category: Mechanical Equipment; Family Name: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVV_INT-EN; Fan Quantity: 1; Fan Type: 3 Speed DC; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Elevation: 0 mm
Dimensions - Area: 5.94559 m2; Ceiling Offset: 0 mm; Volume: 1.29199 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Power,Hydronic Supply,Sanitary
Mechanical - Loads - Sound Pressure Level (dB(A)): 37
Other - Angle: 90 deg; Back Clearance Safe: 50 mm; Bottom Clearance Sfe: 0 mm; Family: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVV_INT-EN: AVV-27URSCB; Family and Type: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVV_INT-EN: AVV-27URSCB; Front Clearance Safe: 500 mm; Gas Connector Angle: 0 deg; Gas Connector Length: 137 mm; Height Connector: 204 mm; Left Clearance Safe: 300 mm; Liquid Connector Angle: 0 deg; Liquid Connector Length: 112 mm; Position Height: 340 mm; Right Clearance Safe: 500 mm; Sound Pressure Level for Ceiling: 34; Sound Pressure Level for Wall: 37; Type: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVV_INT-EN: AVV-27URSCB; Type Id: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVV_INT-EN: AVV-27URSCB
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 50 mm; Bottom Clearance: 100 mm; Ceiling Position: no; Floor Position: yes; Front Clearance: 500 mm; Left Clearance: 300 mm; Rear Connection: yes; Right Clearance: 500 mm; Right Connection: no; Service Space: no
